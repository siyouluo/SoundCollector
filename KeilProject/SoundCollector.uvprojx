# Keil uVision project SoundCollector.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SoundCollector +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\App;.\User;.\Libraries\CMSIS;.\Public
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c
  group App
    ./App/: IndicatorLight.c adc.c
  group Public
    ./Public/: system.c SysTick.c usart1.c timer.c usart2.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
